/*
 * Copyright (C) 2016  Nexell Co., Ltd.
 * Author: Hyejung Kown <cjscld15@nexell.co.kr>
 *
 * This program is free software; you can redistribute it and/or
 * modify it under the terms of the GNU General Public License
 * as published by the Free Software Foundation; either version 2
 * of the License, or (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 */

#include <dt-bindings/interrupt-controller/irq.h>
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/input/input.h>
#include "../../../../../include/generated/autoconf.h"
#include "s5p6818-mmc-ascending-order.dtsi"

#define PMIC_PDATA_INIT(_id, _rname, _minuv,    \
                        _maxuv, _init_uv, _init_enable,         \
                        _set_init_uV, _slp_slots)       \
                regulator-name = _rname;                \
                regulator-min-microvolt = <_minuv>;     \
                regulator-max-microvolt = <_maxuv>;     \
                nx,id = <_id>;                          \
                nx,init_enable = <_init_enable>;        \
                nx,init_uV = <_init_uv>;                \
                nx,set_init_uV = <_set_init_uV>;        \
                nx,sleep_slots = <_slp_slots>;

/ {
	memory {
		device_type = "memory";
		reg = <0x40000000 0x3DF00000>;
	};

	nx-v4l2 {
		status = "okay";
	};

	soc {
		#include "s5p6818-pinctrl.dtsi"
		clocks {
			uart0:uart@c00a9000 { clock-frequency = <147500000>; };
			uart3:uart@c00ab000 { clock-frequency = <147500000>; };
			i2c0:i2c@c00ae000 { clock-frequency = <100000000>; };
			i2c2:i2c@c00b0000  { clock-frequency = <100000000>; };
			pwm0:pwm0@c00ba000 {
				clk-input = <I_PLL2>;
				clock-frequency = <10000000>;
			};
			pwm1:pwm1@c00ba000 {
				clk-input = <I_PLL2>;
				clock-frequency = <10000000>;
			};
			pwm2:pwm2@c00be000 {
				clk-input = <I_PLL2>;
				clock-frequency = <10000000>;
			};
			pwm3:pwm3@c00be000 {
				clk-input = <I_PLL2>;
				clock-frequency = <10000000>;
			};
		};

		dynamic-freq@bb000 {
			supply_name = "vdd_core_regulator";
			vdd_core_regulator-supply = <&VCC_DCDC1>;
		};

		serial0:serial@c00a1000 {
			status = "okay";
		};

		serial3:serial@c00a3000 {
			status = "okay";
		};

		amba {
			pl08xdma0:pl08xdma@c0000000 {
				use_isr;
			};

			pl08xdma1:pl08xdma@c0001000 {
				use_isr;
			};
		};

		tmuctrl_0: tmuctrl@c0096000 {
			status = "okay";
		};

		thermal-zones {
			cpu0_thermal: cpu0-thermal {
				thermal-sensors = <&tmuctrl_0>;
				polling-delay-passive = <1000>;
				polling-delay = <1000>;
				trips {
					cpu_alert0: cpu-alert-0 {
						temperature = <80000>;
						hysteresis = <0>;
						type = "active";
					};
					cpu_alert1: cpu-alert1 {
						temperature = <85000>;
						hysteresis = <0>;
						type = "active";
					};
					cpu-crit-0 {
						temperature = <115000>;
						hysteresis = <0>;
						type = "critical";
					};
				};

				cooling-maps {
					map0 {
						trip = <&cpu_alert0>;
						cooling-device = <&cpu0 0 9>;
					};
					map1 {
						trip = <&cpu_alert1>;
						cooling-device = <&cpu0 9 10>;
					};
				};
			};
		};

		watchdog@c0019000 {
			status = "okay";
		};

		rtc@c0010c00 {
			status = "okay";
		};

		nexell_usbphy: nexell-usbphy@c0012000 {
			status = "okay";
		};

		ehci@c0030000 {
			status = "okay";
			port@0 {
				status = "okay";
			};
		};

		ohci@c0020000 {
			status = "okay";
			port@0 {
				status = "okay";
			};
		};

		dwc2otg@c0040000 {
			status = "okay";
		};

		gmac0:ethernet@c0060000 {
			pinctrl-names = "default";
			pinctrl-0 = <&gmac_pins>;

			status = "okay";
			#address-cells = <0x1>;
			#size-cells = <0x0>;

			snps,phy-addr = <3>;
			snps,reset-gpio = <&gpio_a 10 0>;
			snps,reset-active-low;
			snps,reset-delays-us = <0 10000 30000>;

			boost-busfreq;
			boost-busfreq-timeout = <100000>;

			mdio {
				#address-cells = <1>;
				#size-cells = <0>;

				ethernet_phy: ethernet-phy@3 {
					reg = <3>;
					fixed-link {
						speed = <1000>;
						full-duplex;
					};
				};
			};
		};

		pwm:pwm@c0018000 {
			clock-names = "timers", "pwm-tclk0", "pwm-tclk1";
			clocks = <&pclk>, <&pwm0>, <&pwm2>;
			pinctrl-names = "default";
			pinctrl-0 = <&pwm0_pin &pwm1_pin>;
			samsung,pwm-outputs = <0>, <1>;
			status = "disabled";
		};

		pinctrl@C0010000 {
		    pmic_irq:pmic_irq{
		        nexell,pins = "alive-1";
		        nexell,pin-function = <NX_PIN_FUNC0>;
		        nexell,pin-pull = <NX_PIN_PULL_UP>;
		        nexell,pin-strength = <NX_PIN_STR0>;
		    };
		};
	};	/*** soc ***/

	nexell-ion@0 {
		compatible = "nexell,ion";

		heap_sys_user@0 {
			heap-type = "ion_system";
		};

		heap_sys_contig@0 {
			heap-type = "ion_system_contig";
		};

		heap_dma@0 {
			heap-type = "ion_dma";
		};
	};

	backlight: pwm-backlight {
		compatible = "pwm-backlight";
		pwms = <&pwm 0 20000 1>;
		pwm-names = "pwm-backlight";
		enable-gpios = <&gpio_e 12 0>;

		brightness-levels = <30 31 32 33 34 35 36 37 38 39
				     40 41 42 43 44 45 46 47 48 49
				     50 51 52 53 54 55 56 57 58 59
				     60 61 62 63 64 65 66 67 68 69
				     70 71 72 73 74 75 76 77 78 79
				     80 81 82 83 84 85 86 87 88 89
				     90>;
		default-brightness-level = <45>;
		status = "okay";
	};

};

&dp_drm {
	status = "okay";
	ports {
		port@0 {
			reg = <0>;
			back_color = < 0x0 >;
			color_key = < 0x0 >;
			plane-names = "rgb", "primary", "video";
		};
		port@1 {
			reg = <1>;
			back_color = < 0x0 >;
			color_key = < 0x0 >;
			plane-names = "video", "primary";
		};
	};
};

&dp_drm_lvds {
	status = "ok";
	format = <0x1>; /* JEIDA */
	width-mm = <155>;
	height-mm = <90>;

	display-timing {
		clock-frequency = <55555000>;
		hactive = <1024>;
		vactive = <600>;
		hfront-porch = <160>;
		hback-porch = <140>;
		hsync-len = <20>;
		vfront-porch = <12>;
		vback-porch = <20>;
		vsync-len = <3>;
	};

	dp_control {
		clk_src_lv0 = <2>;
		clk_div_lv0 = <12>;
		clk_src_lv1 = <7>;
		clk_div_lv1 = <1>;
		out_format = <2>;
		invert_field = <1>;
	};
};

&dw_mmc_0 {
	num-slots = <1>;
	bus-width = <4>;
	cap-mmc-highspeed;
	broken-cd;
	non-removable;
	clock-frequency = <50000000>;
	card-detect-delay = <200>;
	disable-wp;
	nexell,drive_dly = <0x0>;
	nexell,drive_shift = <0x02>;
	nexell,sample_dly = <0x00>;
	nexell,sample_shift = <0x01>;
	status = "okay";
};

&dw_mmc_1 {
	num-slots = <1>;
	bus-width = <4>;
	cap-sd-highspeed;
	clock-frequency = <50000000>;
	card-detect-delay = <200>;
	disable-wp;
	cd-gpios = <&gpio_d 21 0>;
	cd-inverted;
	nexell,drive_dly = <0x0>;
	nexell,drive_shift = <0x02>;
	nexell,sample_dly = <0x00>;
	nexell,sample_shift = <0x01>;
	status = "okay";
};

&dw_mmc_2 {
	num-slots = <1>;
	bus-width = <4>;
	cap-sd-highspeed;
	clock-frequency = <50000000>;
	card-detect-delay = <200>;
	disable-wp;
	nexell,drive_dly = <0x0>;
	nexell,drive_shift = <0x02>;
	nexell,sample_dly = <0x00>;
	nexell,sample_shift = <0x01>;
	status = "okay";
};

&i2c_0 {
	#address-cells = <1>;
	#size-cells = <0>;
	status = "okay";

	mp8845c@1c {
		compatible = "nx,mp8845c";
		reg = <0x1c>;
		nx,id = <0>;
		regulators {
			VCC_DCDC1:
				vout1 {PMIC_PDATA_INIT(0,
					"mp8845c_vout0",
					600000, 1500000,
					1250000, 1, 0, 0xF)
					regulator-always-on;
					regulator-boot-on;};
		};
	};
};

&i2c_2 {
	#address-cells = <1>;
	#size-cells = <0>;
	status = "okay";

	mp8845c@1c {
		compatible = "nx,mp8845c";
		reg = <0x1c>;
		nx,id = <1>;
		regulators {
			VCC_DCDC2:
				vout2 {PMIC_PDATA_INIT(1,
					"mp8845c_vout1",
					600000, 1500000,
					1200000, 1, 0, 0xF)
					regulator-always-on;
					regulator-boot-on;};
		};
	};

	nxe2000@32 {
		compatible = "nexell,nxe2000";
		reg = <0x32>;
		interrupt-parent = <&alive_0>;
		interrupts = <0x1 IRQ_TYPE_EDGE_FALLING>;
		pinctrl-names = "default";
		pinctrl-0 = <&pmic_irq>;

		regulators {
			VCC_DCDC3:
				dcdc3 {PMIC_PDATA_INIT(2,
					"nxe2000_dcdc3",
					1000000, 3500000,
					3300000, 1, 1, 0x0)
					regulator-always-on;
					regulator-boot-on;};
			VCC_DCDC4:
				dcdc4 {PMIC_PDATA_INIT(3,
					"nxe2000_dcdc4",
					1000000, 2000000,
					1500000, 1, 0, 0xF)
					regulator-always-on;
					regulator-boot-on;};
			VCC_DCDC5:
				dcdc5 {PMIC_PDATA_INIT(4,
					"nxe2000_dcdc5",
					1000000, 2000000,
					1500000, 1, 0, 0x4)
					regulator-always-on;
					regulator-boot-on;};
			VCC_LDO1:
				ldo1 {PMIC_PDATA_INIT(5,
					"nxe2000_ldo1",
					1000000, 3500000,
					3300000, 0, 1, 0x0)};
			VCC_LDO2:
				ldo2 {PMIC_PDATA_INIT(6,
					"nxe2000_ldo2",
					1000000, 3500000,
					1800000, 0, 1, 0x0)};
			VCC_LDO3:
				ldo3 {PMIC_PDATA_INIT(7,
					"nxe2000_ldo3",
					1000000, 3500000,
					1800000, 1, 1, 0x2)
					regulator-always-on;
					regulator-boot-on;};
			VCC_LDO4:
				ldo4 {PMIC_PDATA_INIT(8,
					"nxe2000_ldo4",
					1000000, 3500000,
					1800000, 1, 1, 0x2)
					regulator-always-on;
					regulator-boot-on;};
			VCC_LDO5:
				ldo5 {PMIC_PDATA_INIT(9,
					"nxe2000_ldo5",
					1000000, 3500000,
					2800000, 0, 1, 0x0)};
			VCC_LDO6:
				ldo6 {PMIC_PDATA_INIT(10,
					"nxe2000_ldo6",
					1000000, 3500000,
					3300000, 1, 1, 0xF)
					regulator-always-on;
					regulator-boot-on;};
			VCC_LDO7:
				ldo7 {PMIC_PDATA_INIT(11,
					"nxe2000_ldo7",
					1000000, 3500000,
					2800000, 1, 1, 0x1)
					regulator-always-on;
					regulator-boot-on;};
			VCC_LDO8:
				ldo8 {PMIC_PDATA_INIT(12,
					"nxe2000_ldo8",
					1000000, 3500000,
					3300000, 0, 1, 0x0)};
			VCC_LDO9:
				ldo9 {PMIC_PDATA_INIT(13,
					"nxe2000_ldo9",
					1000000, 3500000,
					3300000, 0, 1, 0x0)};
			VCC_LDO10:
				ldo10 {PMIC_PDATA_INIT(14,
					"nxe2000_ldo10",
					1000000, 3500000,
					1200000, 1, 1, 0x0)
					regulator-always-on;
					regulator-boot-on;};
			VCC_RTC1:
				ldortc1 {PMIC_PDATA_INIT(15,
					"nxe2000_rtc1",
					1700000, 3500000,
					1800000, 1, 1, 0xF)
					regulator-always-on;
					regulator-boot-on;};
			VCC_RTC2:
				ldortc2 {PMIC_PDATA_INIT(16,
					"nxe2000_rtc2",
					1000000, 3500000,
					1000000, 1, 1, 0xF)
					regulator-always-on;
					regulator-boot-on;};
		};
	};
};
